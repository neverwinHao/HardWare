# Keil uVision project Calendar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Calendar +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd12864.c lcd.h key.c key.h DS1302.c DS1302.h jq8900.c jq8900.h dht11.h dht11.c lunar.c lunar.h lunarword.c lunarword.h
